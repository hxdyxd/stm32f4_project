# Keil uVision project hellof4.uvprojx, settings and files
target hellof4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: hellof4
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,CODE_TYPE_IAP
  c misc: --C99
  c include: ../Inc;     ../Drivers/STM32F4xx_HAL_Driver/Inc;     ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;     ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;     ../Drivers/CMSIS/Include;     ..\App;     ..\App\hardware;     ../Middlewares/Third_Party/FatFs/src/drivers;     ../Middlewares/Third_Party/FatFs/src;    ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;  ../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Inc;  ../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Inc;  ../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc;  ../Middlewares/ST/STM32_USB_Host_Library/Class/MTP/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c fmc.c usart.c rng.c gpio.c i2c.c dma.c fatfs.c usbh_conf.c usb_host.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_ll_fmc.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_hcd.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ioreq.c usbh_core.c usbh_ctlreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_scsi.c usbh_msc.c usbh_msc_bot.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid.c usbh_hid_parser.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MTP/Src/: usbh_mtp.c usbh_mtp_ptp.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Src/: usbh_audio.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
  group App/Hardwaer
    ../App/hardware/: sdram_is42s16400j.c
  group App
    ../App/: soft_timer.c user_main.c debug_uart.c
software components: CMSIS:CORE 4.1.0
